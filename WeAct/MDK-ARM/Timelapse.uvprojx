# Keil uVision project Timelapse.uvprojx, settings and files
target Timelapse (6190000::V6.19::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2401FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Timelapse +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H723xx,USER_VECT_TAB_ADDRESS
  c misc: -std=c11 -Wall -Wextra -Wno-unused-parameter -O2
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Core/Bsp;../Core/Bsp/Camera;../Core/Bsp/ST7735;../Core/Bsp/Storage;../Core/Camera;../Core/Common;../Core/Media;../Core/Recording;../Core/Storage;../Core/Storage/FatFs;../Core/Timelapse;../Core/UI;../USB_HOST/App;../USB_HOST/Target;../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Inc;../Core/Bsp/USB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x20000
  scatter file: Timelapse.sct
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dcmi.c dma.c i2c.c sdmmc.c spi.c tim.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_hcd.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dcmi.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Core/Bsp
    ../Core/Bsp/: board.c board.h
    ../Core/Bsp/Camera/: camera_port.c ov5640.c ov7725.c ov7725_regs.c ov7725_regs.h sensor.h
    ../Core/Bsp/ST7735/: display_port.c st7735.c st7735.h st7735_reg.c st7735_reg.h
    ../Core/Bsp/Storage/: diskio.c store_fatfs.c
    ../Core/Bsp/USB/: usb_link.c usb_link.h
  group Core/Camera
    ../Core/Camera/: camera.h
  group Core/Common
    ../Core/Common/: button.c button.h clock.c clock.h font.c font.h
  group Core/Media
    ../Core/Media/: avi.c avi.h image_text.c image_text.h avi_extended.c avi_extended.h
  group Core/Recording
    ../Core/Recording/: recording.c recording.h download.c download.h
  group Core/Storage
    ../Core/Storage/FatFs/: diskio.h ffunicode.c ff.c ff.h ffconf.h
    ../Core/Storage/: store.h
  group Core/Timelapse
    ../Core/Timelapse/: timelapse_config.c timelapse_config.h timelapse_main.c timelapse_main.h time_sync.c time_sync.h esp_control.c esp_control.h
  group Core/UI
    ../Core/UI/: display.h ui.c ui.h
  group Application/User/USB_HOST/App
    ../USB_HOST/App/: usb_host.c
  group Application/User/USB_HOST/Target
    ../USB_HOST/Target/: usbh_conf.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Src/: usbh_cdc.c
